Commit message: Made eval for model learning, need to test

File: src/envs/bullet_cartpole/hangpole_goal_cont_variable/target.urdf (robot description, URDF)
Before this commit: robot target, 1 links, 0 joints
Links:
- removed link pole
- added link target, mass 0.0; visual sphere radius=0.1
