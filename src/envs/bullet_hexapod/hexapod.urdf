Commit message: c

File: src/envs/bullet_hexapod/hexapod.urdf (robot description, URDF)
Before this commit: robot quadruped, 19 links, 18 joints
Links:
- link torso: geometry collision box size=0.20 0.12 0.06; visual box size=0.20 0.12 0.04
